# Keil uVision project project.uvprojx, settings and files
target robot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\User\drivers;..\User\applications;..\ST_Library\STM32F4xx_StdPeriph_Driver\inc;..\ST_Library\CMSIS\ST\STM32F4xx\Include;..\RT_Thread\include;..\RT_Thread\libcpu\arm\cortex-m4;..\RT_Thread\libcpu\arm\common;..\RT_Thread\components\drivers\include;..\ST_Library\CMSIS\Include;..\RT_Thread\components\finsh;.;..\User\applications;..\User\drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers
    ../User/drivers/: drv_hwtimer.c board.c gpio.c stm32f4_rtc.c stm32f4xx_it.c delay.c app_uart.c usart.c rt_led.c mlx906.c rt_oled.c rt_key.c rt_pwm.c cw_adc.c bsp_ads1115.c hx711.c
    ../User/applications/: soft_timer.c
  group Applications
    ../User/applications/: application.c startup.c canapp.c
    ../User/drivers/: operation.c JY61.c map.c
  group STM32_StdPeriph
    ../ST_Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../ST_Library/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../ST_Library/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Kernel
    ../RT_Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M4
    ../RT_Thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../RT_Thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../RT_Thread/components/drivers/serial/: serial.c
    ../RT_Thread/components/drivers/src/: completion.c pipe.c ringbuffer.c dataqueue.c waitqueue.c workqueue.c
  group finsh
    ../RT_Thread/components/drivers/misc/: pin.c
    ../RT_Thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group text
    ../text/: text.txt track.txt
